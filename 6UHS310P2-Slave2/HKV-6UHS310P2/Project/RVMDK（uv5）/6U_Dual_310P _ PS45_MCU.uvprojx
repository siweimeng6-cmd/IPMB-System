# Keil uVision project 6U_Dual_310P _ PS45_MCU.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HKV-6UHS310P2_260312 +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\ipmb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.h stm32f10x_it.c bsp_init.c bsp_i2c.c bsp_mo_i2c.c bsp_bpd20550.c bsp_adc.c bsp_temp.c func_pwm.c task_usart.c
    ../../User/usart/: bsp_usart.c
    ../../User/timer/: bsp_timer.c bsp_pwm.c
    ../../User/gpio/: bsp_gpio.c
    ../../: log.txt
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../../Doc/: readme.txt 引脚功能汇总.md
    ../../: 对话.txt 指令解析.txt IPMB_测试说明.md
  group IBMP
    ../../User/ipmb/: bsp_i2c_slave.c ipmb_fru.c ipmb_protocol.c ipmb_sensor.c ipmb_slave.c task_ipmb.c bsp_i2c_master.c task_ipmb_master.c
