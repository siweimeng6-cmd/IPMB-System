# Keil uVision project 6UFT5K32_MCU.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: HKV-6UFT5K32-M128 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\uart;..\..\User\key;..\..\User\led;..\..\User\PWM;..\..\User\I2C;..\..\User\ADC;..\..\User\gpio;..\..\lwip-1.4.1\src\include\lwip;..\..\User\ethernet;..\..\User\ethernet\LAN8742A;..\..\lwip-1.4.1\src\include;..\..\lwip-1.4.1\port;..\..\lwip-1.4.1\src\include\ipv4;..\..\lwip-1.4.1\port\Standalone;..\..\User\systick;..\..\lwip-1.4.1\port\STM32F4x7;..\..\User\ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../User/: main.c bsp_init.c stm32f4xx_it.c FreeRTOSConfig.h
    ../../User/uart/: bsp_usart.c
    ../../User/PWM/: bsp_pwm.c func_pwm.c
    ../../User/ADC/: bsp_adc.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/I2C/: bsp_i2c.c bsp_mo_i2c.c bsp_eeprom.c bsp_temp.c bsp_bpd20550.c
    ../../: 指令.txt
  group TASK
    ../../User/uart/: task_usart.c
    ../../User/I2C/: task_i2c.c task_web_sensor.c ipmb_request_builder.c task_slot_cache.c task_slot_poll.c task_ctrl_dispatch.c
    ../../User/ethernet/: task_ethernet.c
    ../../User/PWM/: task_pwm.c
  group ETHERNET
    ../../User/ethernet/: netconf.c stm32f4x7_eth.c UDPBase.c pQueue.c bsp_ethernet.c LY1210.c bsp_httpd.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group LWIP_CORE
    ../../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_ARC
    ../../lwip-1.4.1/src/netif/: etharp.c
    ../../lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group LWIP_API
    ../../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
