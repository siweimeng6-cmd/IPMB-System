# Keil uVision project J2I-BMC.uvprojx, settings and files
target J2I-BMC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08008000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HKV-6UD2K-J2I-BMC-app-0814 +hex
  AfterMake: fromelf.exe --bin -o "..\..\testbin\app_latest_ota.bin" "..\..\Output\HKV-6UD2K-J2I-BMC-app-0805.axf"
  c flags: Optim=1 uC99=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, VECT_TAB_OFFSET=0x8000
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\User\ipmb;..\..\User\adc;..\..\User\i2c;..\..\User\gpio;..\..\User\timer;..\..\User\usart;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\Key
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.h stm32f10x_it.c bsp_init.c bsp_i2c.c
    ../../User/usart/: bsp_usart.c bsp_basicmode.c task_fw_update.c task_usart.c
    ../../User/timer/: bsp_timer.c func_pwm.c bsp_fan_pwm.c task_fan.c
    ../../User/gpio/: bsp_gpio.c task_gpio.c
    ../../User/adc/: bsp_adc.c
    ../../User/i2c/: bsp_mo_i2c.c bsp_temp.c bsp_bpd20550.c bsp_eeprom.c
    ../../: log.txt
  group IPMB
    ../../User/ipmb/: ipmb_protocol.c bsp_i2c_slave.c bsp_i2c_master.c ipmb_slave.c ipmb_sensor.c ipmb_fru.c task_ipmb.c task_ipmb_master.c
    ../../: 指令.txt
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
