# Keil uVision project J2I-BMC-Bootloader.uvprojx, settings and files
target J2I-BMC-Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: J2I-BMC-Bootloader +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\CMSIS;..\..\..\Bootloader;..\..\..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group BOOTLOADER
    ../../../Bootloader/: main.c stm32f10x_conf.h bsp_bl_tick.c bsp_bl_usart.c bsp_flash_iap.c bb_protocol.c
